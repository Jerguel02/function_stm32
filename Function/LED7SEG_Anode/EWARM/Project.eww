<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\LED7SEG_Anode.ewp</path>
  </project>
  <batchBuild />
</workspace>
